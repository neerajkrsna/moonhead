require recipes-core/images/core-image-minimal.bb

SUMMARY = "CORE-OS reference image for initial x86-64 QEMU validation"
